# Keil uVision project RTOSDemo.uvproj, settings and files
target EDF (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RTOSDemo
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM7_LPC21xx_KEIL_RVDS
  c include: .;..\..\Source\portable\RVDS\ARM7_LPC21xx;..\Common\include;..\..\Source\include
  asm include: ..\..\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Other
    ./: Startup.s
    ./ParTest/: ParTest.c
    ./serial/: serialISR.s
    ./Starter_Files_V1/source/: GPIO.c GPIO_cfg.c main.c serial.c
    ./Starter_Files_V1/header/: portASM.s portmacro.inc
  group FreeRTOS
    ./Starter_Files_V1/source/: heap_2.c list.c port.c queue.c serial.c tasks.c
target RTOSDemo_THUMB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC2129 NXP (founded by Philips)
  cpu: as above
  output: RTOSDemo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: ARM7_LPC21xx_KEIL_RVDS KEIL_THUMB_INTERWORK
  c include: .\Starter_Files_V1\header;.\Starter_Files_V1\lib;.\Starter_Files_V1\source;.\Starter_Files_V1\header;.\serial
  asm include: ..\..\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
